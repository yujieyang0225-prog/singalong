## yujie/chip/banner/Kconfig
```kconfig
config KERNEL_SA_BANNER
    bool "Sing-along display banner (pass-through)"
    default n
    select SPIM
    select GPIO
    select SDMA
```
